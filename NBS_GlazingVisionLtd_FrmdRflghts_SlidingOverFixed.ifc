Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2017-01-25T16:01:16
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 15.7.0.0 - Alternate UI 15.7.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Wed Jan 25 16:01:16 2017* Host: NCL-PI08* Database: C:\Users\KovacsG\AppData\Local\Temp\{BD263323-7302-44ED-BDAF-BEAB8741B754}\ifc* Database version: 5507* Database creation date: Wed Jan 25 16:01:16 2017* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Wed Jan 25 16:01:16 2017* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Wed Jan 25 16:01:16 2017* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: X:\NBL\Manufacturer\G\Glazing Vision_12688\NBLA0680\Authoring\IFC\NBS_GlazingVisionLtd_FrmdRflghts_SlidingOverFixed.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcWindow: DoubleGlazed-1500x1500mm_6-18-6mm, NBS_GlazingVisionLtd_FrmdRflghts_SlidingOverFixed:DoubleGlazed-1500x1500mm_6-18-6mm:187828
In: Level 1
Type - ConstructionType: OTHER_CONSTRUCTION; OperationType: SINGLE_PANEL; ParameterTakesPrecedence: no; Sizeable: no; Classification: Pr_30_59_72_31 (Uniclass2015); Material: NBS_Concept, NBS_Glass_Double
Type - NBS_General - Author: NBS; BIMObjectName: NBS_GlazingVisionLtd_FramedRooflights_SlidingOverFixed_DoubleGlazed; ManufacturerName: Glazing Vision Ltd; ManufacturerURL: www.glazingvision.co.uk; NBSCertification: www.nationalbimlibrary.com/cert/cmf1qstq; NBSDescription: Framed rooflights; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 45-25-99/410; NBSTypeID: n/a; ProductInformation: www.glazingvision.co.uk/rooflights/sliding-rooflights/sliding-over-fixed-rooflight/; Revision: n/a; Uniclass2015Code: Pr_30_59_72_31; Uniclass2015Title: Framed rooflights; Uniclass2015Version: Products v1.3; Version: 1
Type - NBS_Data - Accessories: Remote control, Rain sensor, Thermostat, BMS integration, External key switch, Proximity detection, RITEC coating, External keypad; CavityType: 18 mm black silicone sealed warm edge argon filled; Certification: n/a; Configuration: Solo or integrated; DriveMechanism: Twin drive rack and pinion with solenoid security as one way clutch; Form: Flat rectangular; FrameFinishCoating: Qualicoat approved polyester powder coating; FrameFinishColour: RAL 7015 Grey (Outer), RAL 9010 White (Inner); FrameFinishTexture: n/a; FrameMaterial: Aluminium; GlazingOptions: Double, triple; GlazingOrInfillCoating: Low-e coating; GlazingOrInfillConstruction: Double glazed; GlazingOrInfillType: Insulating glass unit; InnerPaneType: 6 mm heat soak tested soft low e toughened; IntermediatePaneType: n/a; MaximumArea: 10.0 m²; MaximumSize: 3100 mm span x 5000 mm width; MinimumSize: 1300 mm span x 1500 mm width; OpeningAngle: n/a; OpeningType: Sliding for ventilation or access; OperationControl: OR Control board and magnetic limit switches; OperationType: 24 V battery operated, 240 V mains supply; OuterPaneType: 6 mm heat soak tested toughened; PitchAngleRange: 3-45°; RooflightWeight: 190 kg (1500 x 1500 mm); Seals: Primary sliding compression seal, secondary PVC coated foam seal; Security: Anti-lifting mechanism to prevent disengagment of drive mechanism via vertical movement of sliding frame; StructuralKerb: To builders kerb (by others) min 142 mm wide, 150 mm high, 3° pitch; ThermalBreak: yes; WholeWindowUValue: 2.5 W/m²K Uw
Type - Pset_WindowCommon - AcousticRating: 31 db; FireRating: n/a; GlazingAreaFraction: 0; Infiltration: 0; IsExternal: yes; Reference: n/a; SecurityRating: n/a; SmokeStop: no; ThermalTransmittance: 2
Type - Pset_DoorWindowGlazingType - BeamRadiationTransmittance: 0; FillGas: Argon; GlassColor: Clear; GlassLayers: 2; GlassThickness1: 6 mm; GlassThickness2: 6 mm; GlassThickness3: 0 mm; IsCoated: yes; IsLaminated: no; IsTempered: yes; IsWired: no; Reflectivity: 0; SolarHeatGainTransmittance: 0; ThermalTransmittanceSummer: 0; ThermalTransmittanceWinter: 0; Translucency: 0
Type - Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 0; HasProtectiveEarth: no; InsulationStandardClass: n/a; IP_Code: n/a; NominalCurrent: 0; NominalFrequencyRange: n/a; NominalVoltage: 24 V battery , 240 V mains; NumberOfPoles: 0; PhaseAngle: 0; PhaseReference: n/a; UsageCurrent: 0
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_30_59_72_31: Framed rooflights; CodePerformance: n/a; Color: Grey/white frame, clear glass; Constituents: Aluminium frame, double IGU; Description: Larger double glazed sliding rooflight for ventilation or access, sliding section travels over fixed section of glazing providing 50% clear opening, rooflight footprint remains the same open or closed; DurationUnit: year; ExpectedLife: n/a; Features: 50% clear opening, manual override as standard, thermally broken frame, minimal footprint on roof; Finish: n/a; Grade: n/a; Manufacturer: sales@glazingvision.co.uk; Material: Aluminium, glass; ModelNumber: 603; ModelReference: GV Standard Sliding Over Fixed Double Glazed Rooflight; Name: FramedRooflights_SlidingOverFixed_DoubleGlazed_GlazingVisionLtd; NominalHeight: 0 mm; NominalLength: 1500 mm; NominalWidth: 1500 mm; ReplacementCost: n/a; Shape: Rectangular; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: Manufacturer's warranty; WarrantyDurationLabor: n/a; WarrantyDurationParts: 2 (installed by others) or 10 years (installed by Glazing Vision); WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: customerservices@glazingvision.co.uk
OverallHeight: 352.563 mm; OverallWidth: 1500 mm
NBS_Data - ComponentNumber: n/a; WindowNumber: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
